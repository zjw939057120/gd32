# Keil uVision project GD32F303.uvprojx, settings and files
target GD32F30X_HD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Core\Inc;.\RTT;D:\Libraries\Include;D:\Libraries\Firmware\Peripherals\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ./Core/Src/: gd32f30x_it.c main.c systick.c
  group RTT
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
target GD32F30X_XD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.5.0, Device:GD32F30x_StdPeripherals:ADC 2.2.0, Device:GD32F30x_StdPeripherals:BKP 2.2.0, Device:GD32F30x_StdPeripherals:CAN 2.2.0, Device:GD32F30x_StdPeripherals:CRC 2.2.0, Device:GD32F30x_StdPeripherals:CTC 2.2.0, Device:GD32F30x_StdPeripherals:DAC 2.2.0, Device:GD32F30x_StdPeripherals:DBG 2.2.0, Device:GD32F30x_StdPeripherals:DMA 2.2.0, Device:GD32F30x_StdPeripherals:ENET 2.2.0, Device:GD32F30x_StdPeripherals:EXMC 2.2.0, Device:GD32F30x_StdPeripherals:EXTI 2.2.0, Device:GD32F30x_StdPeripherals:FMC 2.2.0, Device:GD32F30x_StdPeripherals:FWDGT 2.2.0, Device:GD32F30x_StdPeripherals:GPIO 2.2.0, Device:GD32F30x_StdPeripherals:I2C 2.2.0, Device:GD32F30x_StdPeripherals:MISC 2.2.0, Device:GD32F30x_StdPeripherals:PMU 2.2.0, Device:GD32F30x_StdPeripherals:RCU 2.2.0, Device:GD32F30x_StdPeripherals:RTC 2.2.0, Device:GD32F30x_StdPeripherals:SDIO 2.2.0, Device:GD32F30x_StdPeripherals:SPI_I2S 2.2.0, Device:GD32F30x_StdPeripherals:TIMER 2.2.0, Device:GD32F30x_StdPeripherals:USART 2.1.0, Device:GD32F30x_StdPeripherals:WWDGT 2.2.0, Device:GD32F30x_libopt 2.2.0, Device:Startup 2.2.0, Device:Startup 2.2.0
